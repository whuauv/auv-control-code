<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\hal1发送.ewp</path>
  </project>
  <batchBuild />
</workspace>
